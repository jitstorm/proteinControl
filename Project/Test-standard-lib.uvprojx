# Keil uVision project Test-standard-lib.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test-standard-lib +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Fwilb\inc;..\Core;..\Startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: CLOCK.c CLOCK.h DELAY.c DELAY.h main.c stm32f10x_conf.h stm32f10x_it.c USART.c RingBuffer.c shift_register_input.c shift_register.c spi_helper.c protocol.c protocol_v2.c robot_arm_protocol.c PWM.c motor_ctrl.c single_motor.c reversible_motor.c mixer_pwm.c time.c max31855.c stepMotor.c step_dma.c robot_arm.c robot_arm_driver.c robot_arm_sensor.c
  group Core
    ../Core/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group Fwilb
    ../Fwilb/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_tim.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
